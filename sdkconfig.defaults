## sdkconfig.defaults
```kconfig
CONFIG_I2C_MASTER_SCL=22
CONFIG_I2C_MASTER_SDA=21
CONFIG_I2C_MASTER_FREQ_HZ=400000
```
